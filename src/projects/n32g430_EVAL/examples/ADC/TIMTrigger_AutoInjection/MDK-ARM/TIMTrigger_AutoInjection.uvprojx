# Keil uVision project TIMTrigger_AutoInjection.uvprojx, settings and files
target N32G430 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G430C8L7 Nationstech
  pack: Nationstech.N32G430_DFP.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TIMTrigger_AutoInjection +hex
  AfterMake: fromelf --bin --output=.\bin\TIMTrigger_AutoInjection.bin .\Objects\TIMTrigger_AutoInjection.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G430, USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\n32g430_std_periph_driver\inc;..\..\..\..\..\..\firmware\CMSIS\device;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g430.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g430.c
  group FWLB
    ../../../../../../firmware/n32g430_std_periph_driver/src/: misc.c n32g430_adc.c n32g430_gpio.c n32g430_rcc.c n32g430_tim.c n32g430_dma.c
  group USER
    ../src/: main.c n32g430_it.c
  group DOC
    ../: readme.txt
