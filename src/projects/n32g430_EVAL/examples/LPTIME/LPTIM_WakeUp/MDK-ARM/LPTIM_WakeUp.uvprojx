# Keil uVision project LPTIM_WakeUp.uvprojx, settings and files
target N32G430 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G430C8L7 Nationstech
  pack: Nationstech.N32G430_DFP.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LPTIM_WakeUp +hex
  AfterMake: fromelf --bin --output=.\bin\LPTIM_WakeUp.bin .\Objects\LPTIM_WakeUp.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32G430, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\bsp\inc;..\..\..\..\..\..\firmware\n32g430_std_periph_driver\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g430.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g430.c
  group FWLB
    ../../../../../../firmware/n32g430_std_periph_driver/src/: misc.c n32g430_gpio.c n32g430_rcc.c n32g430_lptim.c n32g430_usart.c n32g430_dbg.c n32g430_exti.c n32g430_flash.c n32g430_pwr.c
  group USER
    ../src/: main.c n32g430_it.c
  group BSP
    ../../../../bsp/src/: log.c
  group DOC
    ../: readme.txt
