# IAR project Icache_CoreMask.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G430C8 Nations N32G430C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G430; SYSCLK_SRC=SYSCLK_USE_HSE_PLL
  ICCARM.CCIncludePath2: ..\inc; ..\coremark; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g430_std_periph_driver\inc; ..\..\..\..\..\..\firmware\n32g430_std_periph_driver\inc; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Icache_CoreMask.bin
  ILINK.IlinkOutputFile: Icache_CoreMask.out
  ILINK.IlinkIcfFile: Icache_CoreMask.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group BSP
    ../../../../bsp/src/: log.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g430.c
  group COREMASK
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
  group DOC
    ../: readme.txt
  group FWLIB
    ../../../../../../firmware/n32g430_std_periph_driver/src/: misc.c n32g430_flash.c n32g430_gpio.c n32g430_rcc.c n32g430_usart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g430_EWARM.s
  group USER
    ../src/: main.c n32g430_it.c
